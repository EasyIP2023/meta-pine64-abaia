FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://mdev-fragment.cfg"
